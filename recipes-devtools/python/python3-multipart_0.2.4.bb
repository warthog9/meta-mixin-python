SUMMARY = "Parser for multipart/form-data"
HOMEPAGE = "https://github.com/prometheus/client_python"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=19c02e41e90781e84f25328b600b73d1"

SRC_URI[sha256sum] = "06ba205360bc7096fefe618e4f1e9b2cdb890b4f2157053a81f386912a2522cb"

inherit pypi python_setuptools_build_meta
