#inherit externalsrc
#EXTERNALSRC = "/home/jhawley/git/phc-winner-argon2"
#EXTERNALSRC_BUILD = "/home/jhawley/git/phc-winner-argon2"

# initial_rev: f57e61e19229e23c4445b85494dbf7c07de721cb
